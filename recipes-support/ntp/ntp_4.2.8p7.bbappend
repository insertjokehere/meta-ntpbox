FILES_${PN} += "${sbindir}/ntpq"
